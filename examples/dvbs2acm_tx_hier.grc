options:
  parameters:
    author: AsriFox
    category: '[DVB]/DVB-S2 ACM'
    generate_options: hb
    id: dvbs2acm_tx
    output_language: python
    title: DVB-S2 ACM Transmitter
  states: {}

blocks:
- name: mod_bits_per_sample
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: bitrate / mod_bits_per_sample
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: Accepted Bitrate
    short_id: b
    type: intx
    value: 64800 * 256
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dvbs2acm_bbheader_bb_0
  id: dvbs2acm_bbheader_bb
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: 'True'
    rate_1: C1_4
    rate_2: C1_5_MEDIUM
    rate_3: C1_4
    rolloff: RO_0_20
  states: {}
- name: dvbs2acm_bbscrambler_bb_0
  id: dvbs2acm_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2acm_bch_encoder_bb_0
  id: dvbs2acm_bch_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_interleaver_bb_0
  id: dvbs2acm_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2acm_ldpc_encoder_bb_0
  id: dvbs2acm_ldpc_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_modulator_bc_0
  id: dvbs2acm_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2acm_physical_cc_0
  id: dvbs2acm_physical_cc
  parameters:
    dummyframes: 'False'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps/2)
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: FIR Filter Rolloff Factor
    type: eng_float
    value: '0.2'
  states: {}
- name: taps
  id: parameter
  parameters:
    hide: part
    label: Number of FIR Filter Taps
    type: intx
    value: '200'
  states: {}

connections:
- [blocks_throttle_0, '0', pad_sink_0, '0']
- [dvbs2acm_bbheader_bb_0, '0', dvbs2acm_bbscrambler_bb_0, '0']
- [dvbs2acm_bbscrambler_bb_0, '0', dvbs2acm_bch_encoder_bb_0, '0']
- [dvbs2acm_bch_encoder_bb_0, '0', dvbs2acm_ldpc_encoder_bb_0, '0']
- [dvbs2acm_interleaver_bb_0, '0', dvbs2acm_modulator_bc_0, '0']
- [dvbs2acm_ldpc_encoder_bb_0, '0', dvbs2acm_interleaver_bb_0, '0']
- [dvbs2acm_modulator_bc_0, '0', dvbs2acm_physical_cc_0, '0']
- [dvbs2acm_physical_cc_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [pad_source_0, '0', dvbs2acm_bbheader_bb_0, '0']

metadata:
  file_format: 1
