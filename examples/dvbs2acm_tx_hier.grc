options:
  parameters:
    author: AsriFox
    category: '[DVB]/DVB-S2 ACM'
    generate_options: hb
    id: dvbs2acm_tx_hier
    output_language: python
    title: DVB-S2 ACM Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: bitrate / 4
  states: {}
- name: taps
  id: variable
  parameters:
    value: '200'
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: Accepted bitrate
    short_id: b
    type: intx
    value: 64800*8
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: bitrate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dvbs2acm_bbheader_bb_0
  id: dvbs2acm_bbheader_bb
  parameters:
    framesize: Normal
    goldcode: '0'
    modcod_normal: MC_QPSK_3_4
    modcod_short: '3'
    pilots: 'True'
    rolloff: RO_0_20
  states: {}
- name: dvbs2acm_bbscrambler_bb_0
  id: dvbs2acm_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2acm_bch_encoder_bb_0
  id: dvbs2acm_bch_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_interleaver_bb_0
  id: dvbs2acm_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2acm_ldpc_encoder_bb_0
  id: dvbs2acm_ldpc_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_modulator_bc_0
  id: dvbs2acm_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2acm_physical_cc_0
  id: dvbs2acm_physical_cc
  parameters:
    dummyframes: 'False'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps/2)
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: ''
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: cmd
    optional: 'True'
    type: message
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: FIR Filter rolloff factor
    type: eng_float
    value: '0.2'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: FIR Filter supersampling factor
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_throttle_0, '0', dvbs2acm_bbheader_bb_0, '0']
- [blocks_throttle_0_0, '0', pad_sink_0, '0']
- [dvbs2acm_bbheader_bb_0, '0', dvbs2acm_bbscrambler_bb_0, '0']
- [dvbs2acm_bbscrambler_bb_0, '0', dvbs2acm_bch_encoder_bb_0, '0']
- [dvbs2acm_bch_encoder_bb_0, '0', dvbs2acm_ldpc_encoder_bb_0, '0']
- [dvbs2acm_interleaver_bb_0, '0', dvbs2acm_modulator_bc_0, '0']
- [dvbs2acm_ldpc_encoder_bb_0, '0', dvbs2acm_interleaver_bb_0, '0']
- [dvbs2acm_modulator_bc_0, '0', dvbs2acm_physical_cc_0, '0']
- [dvbs2acm_physical_cc_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [pad_source_0, '0', blocks_throttle_0, '0']
- [pad_source_0_0, out, dvbs2acm_bbheader_bb_0, cmd]

metadata:
  file_format: 1
