options:
  parameters:
    author: asrifox
    generate_options: qt_gui
    id: dvbs2acm_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1280e6
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Es/N0 (dB)
    start: '-3'
    step: '0.1'
    stop: '20'
    value: '10'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: bitrate / 4
  states: {}
- name: taps
  id: variable
  parameters:
    value: '200'
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC reference
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: sqrt(N0)
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: bit rate in bps
    short_id: b
    type: intx
    value: 64800 * 32
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_uint64(32)
    period: '1000'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debugging Level
    type: intx
    value: '1'
  states: {}
- name: dvbs2acm_bbheader_bb_0
  id: dvbs2acm_bbheader_bb
  parameters:
    framesize: Normal
    goldcode: '0'
    modcod_normal: MC_QPSK_3_4
    modcod_short: '3'
    pilots: 'True'
    rolloff: RO_0_35
  states: {}
- name: dvbs2acm_bbscrambler_bb_0
  id: dvbs2acm_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2acm_bch_encoder_bb_0
  id: dvbs2acm_bch_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_interleaver_bb_0
  id: dvbs2acm_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2acm_ldpc_encoder_bb_0
  id: dvbs2acm_ldpc_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_modulator_bc_0
  id: dvbs2acm_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2acm_physical_cc_0
  id: dvbs2acm_physical_cc
  parameters:
    dummyframes: 'False'
  states: {}
- name: dvbs2acm_symbol_sync_cc_0
  id: dvbs2acm_symbol_sync_cc
  parameters:
    damping_factor: '1.0'
    interp_method: '0'
    loop_bw: '0.01'
    n_subfilt: '128'
    rolloff: '0.2'
    rrc_delay: '5'
    sps: '2'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps/2)
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL Freq. Corr. Period
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,6,1
    nconnections: '2'
    size: '64800'
    type: complex
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: Symbol Sync Damping Factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: Symbol Sync Loop BW
    type: eng_float
    value: '0.0045'
  states: {}

connections:
- [analog_agc_xx_0_0, '0', dvbs2acm_symbol_sync_cc_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_uniform_source_x_0, '0', dvbs2acm_bbheader_bb_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_1, '0']
- [blocks_message_strobe_0, strobe, dvbs2acm_bbheader_bb_0, cmd]
- [blocks_probe_rate_0, rate, blocks_message_debug_0_0, print]
- [blocks_throttle_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_1, '0', analog_agc_xx_0_0, '0']
- [blocks_throttle_0_1_0, '0', qtgui_const_sink_x_0, '1']
- [dvbs2acm_bbheader_bb_0, '0', dvbs2acm_bbscrambler_bb_0, '0']
- [dvbs2acm_bbscrambler_bb_0, '0', dvbs2acm_bch_encoder_bb_0, '0']
- [dvbs2acm_bch_encoder_bb_0, '0', dvbs2acm_ldpc_encoder_bb_0, '0']
- [dvbs2acm_interleaver_bb_0, '0', dvbs2acm_modulator_bc_0, '0']
- [dvbs2acm_ldpc_encoder_bb_0, '0', dvbs2acm_interleaver_bb_0, '0']
- [dvbs2acm_modulator_bc_0, '0', blocks_throttle_0_1_0, '0']
- [dvbs2acm_modulator_bc_0, '0', dvbs2acm_physical_cc_0, '0']
- [dvbs2acm_physical_cc_0, '0', interp_fir_filter_xxx_0, '0']
- [dvbs2acm_symbol_sync_cc_0, '0', blocks_probe_rate_0, '0']
- [dvbs2acm_symbol_sync_cc_0, '0', qtgui_const_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
