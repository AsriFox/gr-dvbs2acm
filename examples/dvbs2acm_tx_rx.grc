options:
  parameters:
    category: Custom
    description: DVB-S2 Loopback Tx/Rx Simulation
    generate_options: qt_gui
    id: dvbs2_tx_rx
    output_language: python
    title: DVB-S2 Tx/Rx Simulation
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Es/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: '20'
  states: {}
- name: qtgui_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 'sqrt(N0 * sps) '
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/asrifox/Downloads/sweetnothing8psk_184_56.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '3'
  states: {}
- name: dvbs2acm_rx_hier_0
  id: dvbs2acm_rx_hier
  parameters:
    agc_gain: '1.0'
    agc_rate: '1e-5'
    agc_ref: '1'
    debug: debug
    goldcode: gold_code
    ldpc_max_trials: '20'
    pl_freq_est_period: '20'
    rolloff: RO_0_20
    sps: sps
    sym_sync_damping: '1.0'
    sym_sync_interp_method: '0'
    sym_sync_loop_bw: '0.0045'
    sym_sync_n_subfilt: '128'
    sym_sync_rrc_delay: '5'
  states: {}
- name: dvbs2acm_tx_hier_0
  id: dvbs2acm_tx_hier
  parameters:
    framesize: Normal
    goldcode: gold_code
    modcod_normal: MC_8PSK_3_4
    modcod_short: MC_QPSK_1_4_S
    pilots: PILOTS_ON
    rolloff: RO_0_20
    sps: sps
    sym_rate: sym_rate
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@3
    legend: 'False'
    name: '"PL Sync Output"'
    size: '64800'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output"'
    size: '64800'
    type: complex
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: 64800 * 8
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Simulation
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Phase Recovery
    num_tabs: '4'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', dvbs2acm_tx_hier_0, '0']
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0_0_0, print]
- [blocks_throttle_0, '0', dvbs2acm_rx_hier_0, '0']
- [dvbs2acm_rx_hier_0, '0', blocks_probe_rate_0_0, '0']
- [dvbs2acm_rx_hier_0, '1', qtgui_const_sink_x_1_0, '0']
- [dvbs2acm_rx_hier_0, '2', qtgui_const_sink_x_1, '0']
- [dvbs2acm_tx_hier_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
