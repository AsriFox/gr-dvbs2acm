options:
  parameters:
    category: Custom
    description: DVB-S2 Loopback Tx/Rx Simulation
    generate_options: qt_gui
    id: dvbs2_tx_rx
    output_language: python
    title: DVB-S2 Tx/Rx Simulation
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Es/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: snr
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: qtgui_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: freq_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 'sqrt(N0 * sps) '
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/asrifox/Downloads/sweetnothing8psk_184_56.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"pls"'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '3'
  states: {}
- name: dvbs2acm_bch_decoder_bb_0
  id: dvbs2acm_bch_decoder_bb
  parameters:
    debug_level: debug
  states: {state: disabled}
- name: dvbs2acm_deinterleaver_bb_0
  id: dvbs2acm_deinterleaver_bb
  parameters: {}
  states: {state: disabled}
- name: dvbs2acm_demodulator_cb_0
  id: dvbs2acm_demodulator_cb
  parameters:
    precision: float('Inf')
  states: {state: disabled}
- name: dvbs2acm_ldpc_decoder_bb_0
  id: dvbs2acm_ldpc_decoder_bb
  parameters:
    debug_level: debug
    max_trials: '25'
  states: {state: disabled}
- name: dvbs2acm_ldpc_decoder_hybrid_cb_0
  id: dvbs2acm_ldpc_decoder_hybrid_cb
  parameters:
    debug_level: debug
    infomode: INFO_ON
    max_trials: '25'
  states: {}
- name: dvbs2acm_plsync_cc_0
  id: dvbs2acm_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: debug
    freq_est_period: pl_freq_est_period
    gold_code: gold_code
    multistream: 'False'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: sps
  states: {}
- name: dvbs2acm_rotator_cc_0
  id: dvbs2acm_rotator_cc
  parameters:
    phase_inc: '0.0'
    tag_inc_update: 'False'
  states: {}
- name: dvbs2acm_symbol_sync_cc_0
  id: dvbs2acm_symbol_sync_cc
  parameters:
    damping_factor: sym_sync_damping
    interp_method: '0'
    loop_bw: sym_sync_loop_bw
    n_subfilt: '128'
    rolloff: rolloff
    rrc_delay: '5'
    sps: sps
  states: {}
- name: dvbs2acm_tx_hier_0
  id: dvbs2acm_tx_hier
  parameters:
    framesize: Normal
    goldcode: gold_code
    modcod_normal: MC_8PSK_3_4
    modcod_short: MC_QPSK_1_4_S
    pilots: PILOTS_ON
    rolloff: RO_0_20
    sps: sps
    sym_rate: sym_rate
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: debug
    framesize: normal
    rate: 3/4
    standard: DVB-S2
  states: {state: disabled}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: normal
    rate: 3/4
    standard: DVB-S2
  states: {state: disabled}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: debug
    framesize: normal
    outputmode: OM_MESSAGE
    rate: 3/4
    standard: DVB-S2
  states: {state: disabled}
- name: dvbs2rx_ldpc_decoder_cb_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    constellation: 8PSK
    debug_level: debug
    framesize: normal
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: 3/4
    standard: DVB-S2
  states: {state: disabled}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: simulated carrier frequency offset in Hz
    type: eng_float
    value: '000'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: 8PSK3/4
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@4
    legend: 'False'
    name: '"PL Sync Output"'
    size: '64800'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output"'
    size: '64800'
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '20'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: 64800 * 8
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Simulation
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    num_tabs: '5'
  states: {}

connections:
- [analog_agc_xx_0, '0', dvbs2acm_rotator_cc_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', dvbs2acm_tx_hier_0, '0']
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0_0_0, print]
- [blocks_throttle_0, '0', analog_agc_xx_0, '0']
- [dvbs2acm_bch_decoder_bb_0, '0', blocks_probe_rate_0_0, '0']
- [dvbs2acm_deinterleaver_bb_0, '0', dvbs2acm_ldpc_decoder_bb_0, '0']
- [dvbs2acm_demodulator_cb_0, '0', dvbs2acm_deinterleaver_bb_0, '0']
- [dvbs2acm_ldpc_decoder_bb_0, '0', blocks_tag_debug_0, '0']
- [dvbs2acm_ldpc_decoder_bb_0, '0', dvbs2acm_bch_decoder_bb_0, '0']
- [dvbs2acm_ldpc_decoder_hybrid_cb_0, '0', blocks_probe_rate_0_0, '0']
- [dvbs2acm_plsync_cc_0, '0', dvbs2acm_demodulator_cb_0, '0']
- [dvbs2acm_plsync_cc_0, '0', dvbs2acm_ldpc_decoder_hybrid_cb_0, '0']
- [dvbs2acm_plsync_cc_0, '0', dvbs2rx_ldpc_decoder_cb_0, '0']
- [dvbs2acm_plsync_cc_0, '0', qtgui_const_sink_x_1, '0']
- [dvbs2acm_plsync_cc_0, rotator_phase_inc, dvbs2acm_rotator_cc_0, cmd]
- [dvbs2acm_rotator_cc_0, '0', dvbs2acm_symbol_sync_cc_0, '0']
- [dvbs2acm_symbol_sync_cc_0, '0', dvbs2acm_plsync_cc_0, '0']
- [dvbs2acm_symbol_sync_cc_0, '0', qtgui_const_sink_x_1_0, '0']
- [dvbs2acm_tx_hier_0, '0', blocks_add_xx_0, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', blocks_probe_rate_0_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', blocks_probe_rate_0_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']

metadata:
  file_format: 1
