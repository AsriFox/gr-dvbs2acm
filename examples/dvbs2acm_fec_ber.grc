options:
  parameters:
    category: Custom
    description: DVB-S2 BCH/LDPC BER Simulation
    generate_options: qt_gui
    id: dvbs2_fec_ber
    output_language: python
    title: DVB-S2 FEC BER
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: byte_rate
  id: variable
  parameters:
    value: bitrate / 8
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Es/N0 (dB)
    start: '-3'
    step: '0.1'
    stop: '10'
    value: snr
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: sqrt(N0)
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: bit rate in bps
    short_id: b
    type: intx
    value: '1000000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/asrifox/Downloads/overflowqpsk_276_45.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: byte_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {state: disabled}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {state: disabled}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_4
  states: {state: disabled}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_4
  states: {state: disabled}
- name: dvbs2_bbheader_bb_0
  id: dvbs2_bbheader_bb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_QPSK
    constellation3: MOD_QPSK
    constellation4: MOD_QPSK
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    framesize3: FECFRAME_NORMAL
    framesize4: FECFRAME_NORMAL
    goldcode1: '0'
    goldcode2: '0'
    goldcode3: '0'
    goldcode4: '0'
    nstreams: '1'
    pilots1: PILOTS_ON
    pilots2: PILOTS_OFF
    pilots3: PILOTS_OFF
    pilots4: PILOTS_OFF
    rate1_1: C1_4
    rate1_2: C1_5_MEDIUM
    rate1_3: C1_4
    rate2_1: C1_4
    rate2_2: C1_5_MEDIUM
    rate2_3: C1_4
    rate3_1: C1_4
    rate3_2: C1_5_MEDIUM
    rate3_3: C1_4
    rate4_1: C1_4
    rate4_2: C1_5_MEDIUM
    rate4_3: C1_4
    rolloff: RO_0_20
  states: {}
- name: dvbs2_bbscrambler_bb_0
  id: dvbs2_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2_bch_bb_0
  id: dvbs2_bch_bb
  parameters: {}
  states: {}
- name: dvbs2_interleaver_bb_0
  id: dvbs2_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2_ldpc_bb_0
  id: dvbs2_ldpc_bb
  parameters: {}
  states: {}
- name: dvbs2_modulator_bc_0
  id: dvbs2_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2rx_bbdeheader_bb_0
  id: dvbs2rx_bbdeheader_bb
  parameters:
    debug_level: '0'
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize: frame_size
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    debug_level: '0'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    constellation: constellation
    debug_level: '0'
    framesize: frame_size
    infomode: INFO_ON
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,6,1
    size: '16200'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 13,0,1,1
    label1: BER
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 7,0,6,1
    label1: Input
    label2: Output
    nconnections: '2'
    size: '64800'
    srate: byte_rate
    type: float
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR (or Es/N0) in dB
    type: eng_float
    value: '5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in_bytes
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: in_bytes
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', dvbs2rx_ldpc_decoder_cb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', dtv_dvb_bch_bb_0, '0']
- [blocks_throttle_0, '0', dvbs2_bbheader_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_add_xx_0, '0']
- [dvbs2_bbheader_bb_0, '0', dvbs2_bbscrambler_bb_0, '0']
- [dvbs2_bbscrambler_bb_0, '0', dvbs2_bch_bb_0, '0']
- [dvbs2_bch_bb_0, '0', dvbs2_ldpc_bb_0, '0']
- [dvbs2_interleaver_bb_0, '0', dvbs2_modulator_bc_0, '0']
- [dvbs2_ldpc_bb_0, '0', dvbs2_interleaver_bb_0, '0']
- [dvbs2_modulator_bc_0, '0', blocks_add_xx_0, '0']
- [dvbs2rx_bbdeheader_bb_0, '0', virtual_sink_0_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbs2rx_bbdeheader_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0, '0', fec_ber_bf_0, '1']
- [virtual_source_1, '0', blocks_char_to_float_0, '0']
- [virtual_source_1, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
