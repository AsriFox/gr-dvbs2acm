options:
  parameters:
    author: AsriFox
    generate_options: qt_gui
    id: dvbs2acm_fec_ber
    output_language: python
    title: DVB-S2 ACM FEC BER
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1280e6
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Es/N0 (dB)
    start: '-3'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: bitrate / 2
  states: {}
- name: taps
  id: variable
  parameters:
    value: '200'
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC reference
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: sqrt(N0)
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: bitrate
  id: parameter
  parameters:
    label: bit rate in bps
    short_id: b
    type: intx
    value: '2000000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debugging Level
    type: intx
    value: '1'
  states: {}
- name: dvbs2_bbheader_bb_0
  id: dvbs2_bbheader_bb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_QPSK
    constellation3: MOD_QPSK
    constellation4: MOD_QPSK
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_NORMAL
    framesize3: FECFRAME_NORMAL
    framesize4: FECFRAME_NORMAL
    goldcode1: '0'
    goldcode2: '0'
    goldcode3: '0'
    goldcode4: '0'
    nstreams: '1'
    pilots1: PILOTS_OFF
    pilots2: PILOTS_OFF
    pilots3: PILOTS_OFF
    pilots4: PILOTS_OFF
    rate1_1: C1_4
    rate1_2: C1_5_MEDIUM
    rate1_3: C1_4
    rate2_1: C1_4
    rate2_2: C1_5_MEDIUM
    rate2_3: C1_4
    rate3_1: C1_4
    rate3_2: C1_5_MEDIUM
    rate3_3: C1_4
    rate4_1: C1_4
    rate4_2: C1_5_MEDIUM
    rate4_3: C1_4
    rolloff: RO_0_35
  states: {}
- name: dvbs2acm_bbdescrambler_bb_0
  id: dvbs2acm_bbdescrambler_bb
  parameters: {}
  states: {}
- name: dvbs2acm_bbscrambler_bb_0
  id: dvbs2acm_bbscrambler_bb
  parameters: {}
  states: {}
- name: dvbs2acm_bch_decoder_bb_0
  id: dvbs2acm_bch_decoder_bb
  parameters:
    debug_level: debug
    outputmode: OM_CODEWORD
  states: {}
- name: dvbs2acm_bch_encoder_bb_0
  id: dvbs2acm_bch_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_interleaver_bb_0
  id: dvbs2acm_interleaver_bb
  parameters: {}
  states: {}
- name: dvbs2acm_ldpc_decoder_cb_0
  id: dvbs2acm_ldpc_decoder_cb
  parameters:
    debug_level: debug
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_CODEWORD
  states: {}
- name: dvbs2acm_ldpc_encoder_bb_0
  id: dvbs2acm_ldpc_encoder_bb
  parameters: {}
  states: {}
- name: dvbs2acm_modulator_bc_0
  id: dvbs2acm_modulator_bc
  parameters: {}
  states: {}
- name: dvbs2acm_physical_cc_0
  id: dvbs2acm_physical_cc
  parameters:
    dummyframes: DUMMY_FRAMES_OFF
  states: {}
- name: dvbs2acm_plsync_cc_0
  id: dvbs2acm_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: '0'
    freq_est_period: '10'
    gold_code: '0'
    multistream: 'True'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: '2.0'
  states: {}
- name: dvbs2acm_rotator_cc_0
  id: dvbs2acm_rotator_cc
  parameters:
    phase_inc: '0.0'
    tag_inc_update: 'False'
  states: {}
- name: dvbs2acm_symbol_sync_cc_0
  id: dvbs2acm_symbol_sync_cc
  parameters:
    damping_factor: '1.0'
    interp_method: '0'
    loop_bw: '0.01'
    n_subfilt: '128'
    rolloff: RO_0_35
    rrc_delay: '5'
    sps: '2'
  states: {}
- name: dvbs2acm_bbdeheader_bb_0
  id: dvbs2acm_bbdeheader_bb
  parameters:
    framesize: ''
    rate: ''
    standard: ''
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL Freq. Corr. Period
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,6,1
    size: '16200'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 13,0,1,1
    label1: BER
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: Symbol Sync Damping Factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: Symbol Sync Loop BW
    type: eng_float
    value: '0.0045'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: in_bytes
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: out_bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: in_bytes
  states: {}

connections:
- [analog_agc_xx_0, '0', dvbs2acm_rotator_cc_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_uniform_source_x_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', dvbs2_bbheader_bb_0, '0']
- [dvbs2_bbheader_bb_0, '0', dvbs2acm_bbscrambler_bb_0, '0']
- [dvbs2acm_bbdescrambler_bb_0, '0', dvbs2acm_bbdeheader_bb_0, '0']
- [dvbs2acm_bbscrambler_bb_0, '0', dvbs2acm_bch_encoder_bb_0, '0']
- [dvbs2acm_bch_decoder_bb_0, '0', dvbs2acm_bbdescrambler_bb_0, '0']
- [dvbs2acm_bch_encoder_bb_0, '0', dvbs2acm_ldpc_encoder_bb_0, '0']
- [dvbs2acm_interleaver_bb_0, '0', dvbs2acm_modulator_bc_0, '0']
- [dvbs2acm_ldpc_decoder_cb_0, '0', dvbs2acm_bch_decoder_bb_0, '0']
- [dvbs2acm_ldpc_encoder_bb_0, '0', dvbs2acm_interleaver_bb_0, '0']
- [dvbs2acm_modulator_bc_0, '0', dvbs2acm_physical_cc_0, '0']
- [dvbs2acm_physical_cc_0, '0', fft_filter_xxx_0, '0']
- [dvbs2acm_plsync_cc_0, '0', dvbs2acm_ldpc_decoder_cb_0, '0']
- [dvbs2acm_plsync_cc_0, rotator_phase_inc, dvbs2acm_rotator_cc_0, cmd]
- [dvbs2acm_rotator_cc_0, '0', dvbs2acm_symbol_sync_cc_0, '0']
- [dvbs2acm_symbol_sync_cc_0, '0', dvbs2acm_plsync_cc_0, '0']
- [dvbs2acm_bbdeheader_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fft_filter_xxx_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0, '0', fec_ber_bf_0, '1']
- [virtual_source_1, '0', fec_ber_bf_0, '0']

metadata:
  file_format: 1
